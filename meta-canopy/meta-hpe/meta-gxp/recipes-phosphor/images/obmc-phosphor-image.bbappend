IMAGE_INSTALL:append = " u-boot-gxp-env"
