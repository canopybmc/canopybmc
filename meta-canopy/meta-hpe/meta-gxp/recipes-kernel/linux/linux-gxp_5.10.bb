KBRANCH = "dev-5.10-gxp-openbmc"
LINUX_VERSION = "5.10"
SRCREV = "0afd1d3fd497b6dee44113eae589275adb441f38"

require linux-gxp.inc

#SRC_URI += " file://0001-arm-gxp-add-device-tree-overlay-support-via-configfs.patch"
#SRC_URI += " file://0002-arm-gxp-add-HPE-GXP-SoC-platform-support.patch"
#SRC_URI += " file://0003-arm-gxp-add-GXP-peripheral-drivers.patch"
#SRC_URI += " file://0004-arm-gxp-add-KCS-and-SSIF-IPMI-BMC-drivers.patch"
#SRC_URI += " file://0005-arm-gxp-add-hardware-monitoring-drivers.patch"
#SRC_URI += " file://0006-arm-gxp-add-PECI-bus-driver-and-MFD-updates.patch"
#SRC_URI += " file://0007-arm-gxp-add-thumbnail-video-driver.patch"
#SRC_URI += " file://0008-arm-gxp-add-miscellaneous-platform-support.patch"
