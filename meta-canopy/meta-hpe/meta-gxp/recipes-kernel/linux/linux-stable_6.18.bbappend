FILESEXTRAPATHS:prepend := "${THISDIR}/linux-stable:"
FILESEXTRAPATHS:prepend := "${THISDIR}/linux-stable-6.18:"

require linux-gxp-flash-layout.inc
require linux-gxp-multi-dtb.inc

KCONFIG_MODE = "--alldefconfig"

ERROR_QA:remove = "patch-status"

SRC_URI += "file://defconfig"
SRC_URI += "file://debug.cfg"
SRC_URI += "file://0001-spi-gxp-fix-out-of-bounds-access-in-memory-mapped-re.patch"
SRC_URI += "file://0002-i2c-gxp-fix-use-of-error-pointer-on-syscon-lookup-fa.patch"
SRC_URI += "file://0003-dt-bindings-arm-hpe-simplify-to-generic-GXP-compatib.patch"
SRC_URI += "file://0004-ARM-dts-hpe-gxp-convert-to-standalone-device-tree.patch"
SRC_URI += "file://0005-ARM-dts-hpe-gxp-expand-device-tree-for-boot-support.patch"
SRC_URI += "file://0006-dt-bindings-nvmem-add-HPE-GXP-virtual-EEPROM-binding.patch"
SRC_URI += "file://0007-nvmem-add-HPE-GXP-virtual-EEPROM-driver.patch"
SRC_URI += "file://0008-ARM-dts-hpe-gxp-add-NVMEM-virtual-EEPROM-with-MAC-ad.patch"
SRC_URI += "file://0009-dt-bindings-net-add-HPE-GXP-UMAC-ethernet-controller.patch"
SRC_URI += "file://0010-net-ethernet-add-HPE-GXP-UMAC-driver.patch"
SRC_URI += "file://0011-ARM-dts-hpe-gxp-add-UMAC-ethernet-and-MDIO-nodes.patch"
SRC_URI += "file://0012-dt-bindings-soc-hpe-add-GXP-SoC-subsystem-bindings.patch"
SRC_URI += "file://0013-soc-hpe-add-GXP-SoC-infrastructure-drivers.patch"
SRC_URI += "file://0014-gpio-add-HPE-GXP-GPIO-controller-driver.patch"
SRC_URI += "file://0015-dt-bindings-hwmon-hpe-gxp-fan-ctrl-use-syscon-phandl.patch"
SRC_URI += "file://0016-hwmon-gxp-fan-ctrl-use-syscon-phandles-for-XREG-and-.patch"
SRC_URI += "file://0017-dt-bindings-soc-hpe-add-GXP-host-power-controller-bi.patch"
SRC_URI += "file://0018-soc-hpe-add-GXP-host-power-controller-driver.patch"
SRC_URI += "file://0019-ARM-dts-hpe-gxp-add-SoC-infrastructure-and-power-con.patch"
SRC_URI += "file://0020-soc-hpe-gxp-power-ctrl-implement-ForceRestart-as-VPB.patch"
SRC_URI += "file://0021-dt-bindings-serial-add-HPE-GXP-Virtual-UART-binding.patch"
SRC_URI += "file://0022-serial-8250-add-HPE-GXP-Virtual-UART-driver.patch"
SRC_URI += "file://0023-ARM-dts-hpe-gxp-add-Virtual-UART-node.patch"
SRC_URI += "file://0024-soc-hpe-gxp-power-ctrl-run-full-prepare-boot-sequenc.patch"
SRC_URI += "file://0025-soc-hpe-gxp-power-ctrl-use-CSM-SW_RESET-for-warm-res.patch"
SRC_URI += "file://0026-dt-bindings-soc-hpe-add-GXP-CHIF-binding.patch"
SRC_URI += "file://0027-soc-hpe-add-GXP-CHIF-driver.patch"
SRC_URI += "file://0028-ARM-dts-hpe-gxp-add-CHIF-node.patch"
SRC_URI += "file://0029-hwmon-gxp-fan-ctrl-fix-PWM-register-offset-and-fan-f.patch"
SRC_URI += "file://0030-dt-bindings-regulator-add-HPE-GXP-CPLD-host-power-su.patch"
SRC_URI += "file://0031-regulator-gxp-cpld-add-HPE-GXP-CPLD-host-power-suppl.patch"
SRC_URI += "file://0032-dt-bindings-hwmon-gxp-fan-ctrl-replace-fn2-syscon-wi.patch"
SRC_URI += "file://0033-hwmon-gxp-fan-ctrl-use-fan-supply-regulator-and-fix-.patch"
SRC_URI += "file://0034-dt-bindings-soc-hpe-gxp-fn2-allow-regulator-child-no.patch"
SRC_URI += "file://0035-ARM-dts-hpe-gxp-add-CPLD-host-power-regulator-and-fa.patch"
SRC_URI += "file://0036-hwmon-gxp-fan-ctrl-expose-fan_input-reporting-PWM-du.patch"
SRC_URI += "file://0037-ARM-dts-hpe-gxp-add-gpio-keys-polled-node-for-fan-pr.patch"
SRC_URI += "file://0038-net-ethernet-gxp-fix-DMA-use-after-free-in-umac_stop.patch"
SRC_URI += "file://0039-net-ethernet-gxp-fix-discarded-qualifiers-warning-in.patch"
SRC_URI += "file://0040-soc-hpe-gxp-xreg-fix-format-string-type-for-GENMASK-.patch"
SRC_URI += "file://0041-soc-hpe-gxp-chif-replace-stack-buffer-with-dma_wmb-b.patch"
SRC_URI += "file://0042-soc-hpe-gxp-power-ctrl-demote-PGOOD-deasserted-messa.patch"
SRC_URI += "file://0043-dt-bindings-hwmon-add-HPE-GXP-SoC-temperature-sensor.patch"
SRC_URI += "file://0044-hwmon-gxp-coretemp-add-HPE-GXP-SoC-temperature-senso.patch"
SRC_URI += "file://0045-ARM-dts-hpe-gxp-add-coretemp-sensor-node.patch"
SRC_URI += "file://0046-dt-bindings-regulator-hpe-gxp-host-power-supply-add-.patch"
SRC_URI += "file://0047-soc-hpe-gxp-power-ctrl-use-IRQF_SHARED-for-PGOOD-int.patch"
SRC_URI += "file://0048-regulator-gxp-cpld-fire-notifier-events-on-PGOOD-tra.patch"
SRC_URI += "file://0049-ARM-dts-hpe-gxp-add-PGOOD-interrupt-to-host-power-re.patch"
SRC_URI += "file://0050-peci-core-export-device-lifecycle-helpers-for-contro.patch"
SRC_URI += "file://0051-peci-request-retry-on-unrecognized-completion-codes.patch"
SRC_URI += "file://0052-dt-bindings-peci-add-HPE-GXP-PECI-controller-binding.patch"
SRC_URI += "file://0053-peci-controller-add-HPE-GXP-PECI-controller-driver.patch"
SRC_URI += "file://0054-ARM-dts-hpe-gxp-add-PECI-controller-node.patch"
SRC_URI += "file://0055-peci-cpu-add-Intel-Emerald-Rapids-support.patch"
SRC_URI += "file://0056-hwmon-peci-cputemp-add-Intel-Emerald-Rapids-support.patch"
SRC_URI += "file://0057-hwmon-peci-dimmtemp-add-Intel-Emerald-Rapids-platfor.patch"
SRC_URI += "file://0058-peci-controller-gxp-manage-PECI-devices-via-regulato.patch"
SRC_URI += "file://0059-dt-bindings-hwmon-gxp-fan-ctrl-add-fan-shutdown-perc.patch"
SRC_URI += "file://0060-hwmon-gxp-fan-ctrl-restore-safe-fan-speed-on-shutdow.patch"
SRC_URI += "file://0061-ARM-dts-hpe-gxp-set-fan-shutdown-speed-to-50-percent.patch"
SRC_URI += "file://0062-hwmon-gxp-fan-ctrl-restore-fan-speed-on-kernel-panic.patch"
SRC_URI += "file://0063-peci-core-serialize-device-creation-with-per-control.patch"
SRC_URI += "file://0064-regulator-gxp-cpld-debounce-PGOOD-IRQ-before-notifyi.patch"
SRC_URI += "file://0065-ARM-dts-hpe-gxp-add-mmio-mux-for-i2c-bus-select.patch"
SRC_URI += "file://0066-hwmon-add-HPE-GXP-PSU-driver.patch"
SRC_URI += "file://0067-ARM-dts-hpe-gxp-rename-PSU-GPIO-lines.patch"
SRC_URI += "file://0068-hwmon-sbtsi_temp-add-regulator-supply-and-probe-defe.patch"
SRC_URI += "file://0069-misc-sbrmi-add-regulator-supply-support.patch"
SRC_URI += "file://0070-misc-amd-sbi-add-SB-RMI-revision-0x21-Turin-protocol.patch"
SRC_URI += "file://0071-dt-bindings-soc-hpe-add-GXP-I2C-passthrough-binding.patch"
SRC_URI += "file://0072-soc-hpe-add-GXP-I2C-passthrough-driver.patch"
SRC_URI += "file://0073-ARM-dts-hpe-gxp-add-I2C-passthrough-node.patch"
SRC_URI += "file://0074-gxp-i2c-passthrough-fire-uevent-after-I2C-passthroug.patch"
SRC_URI += "file://0075-ipmi-kcs_bmc_gxp-port-driver-to-Linux-v6.18.patch"
SRC_URI += "file://0076-media-add-GXP-thumbnail-video-capture-driver.patch"
SRC_URI += "file://0077-ARM-dts-hpe-gxp-add-video-thumbnail-and-USB-UDC-node.patch"
SRC_URI += "file://0078-usb-gadget-udc-add-HPE-GXP-USB-device-controller-dri.patch"
SRC_URI += "file://0081-spi-gxp-support-addressed-reads-with-dummy-cycles.patch"
SRC_URI += "file://kvm.cfg"
