PACKAGECONFIG:append = " check-fwupdate-before-do-transition"
