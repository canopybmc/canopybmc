RDEPENDS:${PN}-extras:append = " \
        phosphor-sel-logger \
"

RDEPENDS:${PN}-devtools:remove = " \
        lrzsz \
        rsync \
"
