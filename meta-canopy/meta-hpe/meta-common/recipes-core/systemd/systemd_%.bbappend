PACKAGECONFIG:remove = "seccomp"
