KBRANCH = "main"
LINUX_VERSION = "6.18.7"
SRCREV = "5dfbc5357c34bdf81c84aa78bc8e3d6d9ba10aad"

require linux-canopy.inc
