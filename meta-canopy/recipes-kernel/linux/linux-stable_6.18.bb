KBRANCH = "linux-6.18.y"
LINUX_VERSION = "6.18.25"
SRCREV = "a256b1e6892e7fe840f0f9746316fa938e9a421f"

require linux-stable.inc
