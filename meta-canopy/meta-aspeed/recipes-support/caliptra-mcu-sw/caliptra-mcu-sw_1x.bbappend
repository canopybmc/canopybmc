inherit perlnative

export PERL = "perl"
