CHASSIS_SMP_MAX_INSTANCE:ast2700-a1-dcscm = "0"
