PACKAGES:remove:ast2700-a1-dcscm = " \
    ${PN}-chassis-state-mgmt \
    ${PN}-console \
    ${PN}-fan-control \
    ${PN}-host-check-mgmt \
    ${PN}-host-state-mgmt \
    ${PN}-ikvm \
    "
