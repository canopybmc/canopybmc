PACKAGECONFIG:append:df-dbus-logging = " send-to-logger"

PACKAGECONFIG:append = " log-threshold log-pulse"

