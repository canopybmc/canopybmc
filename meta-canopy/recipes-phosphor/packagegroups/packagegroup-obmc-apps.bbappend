RDEPENDS:${PN}-devtools:remove = "trace-enable"
