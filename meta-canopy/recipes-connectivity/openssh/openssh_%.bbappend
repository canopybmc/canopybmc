PACKAGECONFIG ??= " \
    systemd-sshd-socket-mode \
    hostkey-ed25519 \
    hostkey-ecdsa \
    "
